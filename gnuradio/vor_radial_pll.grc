options:
  parameters:
    generate_options: no_gui
    id: vor_radial_pll
    output_language: python
    title: Decodificador VOR con PLL (radial)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
    comment: Muestreo del RTL-SDR (1.2 MS/s)
  states: {}
- name: env_rate
  id: variable
  parameters:
    value: 100e3
    comment: Muestreo tras decimar por 12
  states: {}
- name: freq
  id: variable
  parameters:
    value: 113.9e6
    comment: Frecuencia del VOR (BOG 113.9 MHz; SOA 108.6 MHz)
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '40'
    comment: Ganancia RF
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '30'
    comment: Ganancia IF
  states: {}
- name: var_bw
  id: variable
  parameters:
    value: '3'
    comment: Ancho de banda del PLL de 30 Hz (Hz)
  states: {}
- name: ref_bw
  id: variable
  parameters:
    value: '300'
    comment: Ancho de banda del PLL de FM de la referencia (Hz)
  states: {}
- name: offset
  id: variable
  parameters:
    value: '270'
    comment: Calibracion del radial (grados), se resta
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    comment: 'RTL-SDR Blog V4. Ganancia manual (no AGC): RF 40, IF 30, BB 20'
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: lp_decim
  id: low_pass_filter
  parameters:
    type: fir_filter_ccf
    decim: '12'
    gain: '1'
    samp_rate: samp_rate
    cutoff_freq: 15e3
    width: 3e3
    win: window.WIN_HAMMING
    comment: 'Pasabajos 15 kHz y decimacion por 12: 1.2 MS/s a 100 kS/s'
  states: {}
- name: envolvente
  id: blocks_complex_to_mag
  parameters:
    comment: 'Envolvente AM: aqui estan los 30 Hz, la subportadora de 9960 Hz y el ident'
  states: {}
- name: bp_var
  id: band_pass_filter
  parameters:
    type: fir_filter_fff
    decim: '1'
    gain: '1'
    samp_rate: env_rate
    low_cutoff_freq: '20'
    high_cutoff_freq: '40'
    width: '15'
    win: window.WIN_HAMMING
    comment: 'VAR: pasabanda 20 a 40 Hz'
  states: {}
- name: hilbert_var
  id: hilbert_fc
  parameters:
    num_taps: '129'
    comment: 'VAR: senal compleja (analitica)'
  states: {}
- name: mixer_var
  id: blocks_multiply_xx
  parameters:
    type: complex
    comment: 'VAR: baja a cerca de 0 Hz con el LO de -30 Hz'
  states: {}
- name: pll_var
  id: analog_pll_refout_cc
  parameters:
    w: 2*math.pi*var_bw/env_rate
    max_freq: 2*math.pi*8/env_rate
    min_freq: '-2*math.pi*8/env_rate'
    comment: 'VAR: PLL de 3 Hz, rango +-8 Hz. Entrega el tono enganchado, limpio'
  states: {}
- name: lo_30
  id: analog_sig_source_x
  parameters:
    type: complex
    samp_rate: env_rate
    waveform: analog.GR_COS_WAVE
    freq: '-30'
    amp: '1'
    offset: '0'
    phase: '0'
    comment: 'Oscilador local de -30 Hz, el MISMO para VAR y REF: no altera la diferencia de fase'
  states: {}
- name: bp_ref
  id: band_pass_filter
  parameters:
    type: fir_filter_fff
    decim: '1'
    gain: '1'
    samp_rate: env_rate
    low_cutoff_freq: '9480'
    high_cutoff_freq: '10440'
    width: '150'
    win: window.WIN_HAMMING
    comment: 'REF: aisla la subportadora de 9960 Hz'
  states: {}
- name: hilbert_ref
  id: hilbert_fc
  parameters:
    num_taps: '129'
    comment: 'REF: senal compleja'
  states: {}
- name: mixer_ref
  id: blocks_multiply_xx
  parameters:
    type: complex
    comment: 'REF: baja la subportadora a 0 Hz'
  states: {}
- name: lo_9960
  id: analog_sig_source_x
  parameters:
    type: complex
    samp_rate: env_rate
    waveform: analog.GR_COS_WAVE
    freq: '-9960'
    amp: '1'
    offset: '0'
    phase: '0'
    comment: Oscilador local de -9960 Hz
  states: {}
- name: pll_fm
  id: analog_pll_freqdet_cf
  parameters:
    w: 2*math.pi*ref_bw/env_rate
    max_freq: 2*math.pi*700/env_rate
    min_freq: '-2*math.pi*700/env_rate'
    comment: 'REF: PLL de 300 Hz que sigue la frecuencia instantanea (demodula la FM, desviacion +-480 Hz)'
  states: {}
- name: bp_ref2
  id: band_pass_filter
  parameters:
    type: fir_filter_fff
    decim: '1'
    gain: '1'
    samp_rate: env_rate
    low_cutoff_freq: '20'
    high_cutoff_freq: '40'
    width: '15'
    win: window.WIN_HAMMING
    comment: 'REF: limpia el tono de 30 Hz ya demodulado'
  states: {}
- name: hilbert_ref2
  id: hilbert_fc
  parameters:
    num_taps: '129'
    comment: 'REF: senal compleja'
  states: {}
- name: mixer_ref2
  id: blocks_multiply_xx
  parameters:
    type: complex
    comment: 'REF: baja a cerca de 0 Hz con el mismo LO de -30 Hz'
  states: {}
- name: pll_ref
  id: analog_pll_refout_cc
  parameters:
    w: 2*math.pi*var_bw/env_rate
    max_freq: 2*math.pi*8/env_rate
    min_freq: '-2*math.pi*8/env_rate'
    comment: 'REF: PLL de 3 Hz, igual al de VAR'
  states: {}
- name: comparador
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: 'Entrada 0 = REF, entrada 1 = VAR (sentido invertido, equivale a --invert). Salida: REF x conj(VAR)'
  states: {}
- name: fase
  id: blocks_complex_to_arg
  parameters:
    comment: Angulo = diferencia de fase (radianes)
  states: {}
- name: a_grados
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: 180/math.pi
    comment: Radianes a grados
  states: {}
- name: calibracion
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '-offset'
    comment: 'Resta el offset de calibracion: radial = fase - 270'
  states: {}
- name: a_20_por_s
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: int(env_rate/20)
    comment: De 100000 muestras/s a 20 valores/s
  states: {}
- name: salida_udp
  id: network_udp_sink
  parameters:
    type: float
    addr: '"127.0.0.1"'
    port: '6006'
    header: '0'
    payloadsize: '40'
    send_eof: 'True'
    comment: UDP 127.0.0.1:6006 hacia el puente o hacia ver_radial.py
  states: {}
- name: nota_titulo
  id: note
  parameters:
    note: Decodificador VOR con PLL (cadena de radial de vor_radial_decoder_pll.py). No incluye el identificador Morse ni el espectro.
  states: {}

connections:
- [rtlsdr_source_0, '0', lp_decim, '0']
- [lp_decim, '0', envolvente, '0']
- [envolvente, '0', bp_var, '0']
- [bp_var, '0', hilbert_var, '0']
- [hilbert_var, '0', mixer_var, '0']
- [lo_30, '0', mixer_var, '1']
- [mixer_var, '0', pll_var, '0']
- [envolvente, '0', bp_ref, '0']
- [bp_ref, '0', hilbert_ref, '0']
- [hilbert_ref, '0', mixer_ref, '0']
- [lo_9960, '0', mixer_ref, '1']
- [mixer_ref, '0', pll_fm, '0']
- [pll_fm, '0', bp_ref2, '0']
- [bp_ref2, '0', hilbert_ref2, '0']
- [hilbert_ref2, '0', mixer_ref2, '0']
- [lo_30, '0', mixer_ref2, '1']
- [mixer_ref2, '0', pll_ref, '0']
- [pll_ref, '0', comparador, '0']
- [pll_var, '0', comparador, '1']
- [comparador, '0', fase, '0']
- [fase, '0', a_grados, '0']
- [a_grados, '0', calibracion, '0']
- [calibracion, '0', a_20_por_s, '0']
- [a_20_por_s, '0', salida_udp, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
