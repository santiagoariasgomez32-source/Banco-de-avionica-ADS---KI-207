options:
  parameters:
    generate_options: qt_gui
    id: com_test_v2
    output_language: python
    title: Receptor COM AM v2 (sincrono)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: offset
  id: variable
  parameters:
    value: 250e3
    comment: Desplazamiento del sintonizador para evitar el pico DC del SDR
  states: {}
- name: freq_mhz
  id: variable_qtgui_range
  parameters:
    label: Frecuencia (MHz)
    value: '127.75'
    start: '118'
    stop: '137'
    step: '0.005'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia RF (dB)
    value: '49.6'
    start: '0'
    stop: '49.6'
    step: '0.1'
  states: {}
- name: squelch_db
  id: variable_qtgui_range
  parameters:
    label: Squelch (dB)
    value: '-31'
    start: '-100'
    stop: '0'
    step: '1'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volumen
    value: '2.0'
    start: '0'
    stop: '6'
    step: '0.05'
  states: {}
- name: bw_khz
  id: variable_qtgui_range
  parameters:
    label: Ancho de canal (kHz)
    value: '4.0'
    start: '1.5'
    stop: '10'
    step: '0.1'
  states: {}
- name: audio_lp
  id: variable_qtgui_range
  parameters:
    label: Audio pasabajos (kHz)
    value: '2.8'
    start: '1'
    stop: '5'
    step: '0.1'
  states: {}
- name: pll_bw
  id: variable_qtgui_range
  parameters:
    label: Ancho del PLL
    value: '0.01'
    start: '0.001'
    stop: '0.1'
    step: '0.001'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq_mhz*1e6+offset
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-offset'
    decim: '25'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, bw_khz*1e3, 1.5e3)
    type: ccf
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.0001'
    threshold: squelch_db
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    type: complex
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    reference: '0.5'
    gain: '1.0'
    max_gain: '300'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    w: pll_bw
    max_freq: '0.3'
    min_freq: '-0.3'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    type: fir_filter_fff
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    cutoff_freq: '300'
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    type: fir_filter_fff
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    cutoff_freq: audio_lp*1e3
    width: '800'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: volume
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq_mhz*1e6+offset
    fftsize: '512'
    name: '"Espectro RF"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/25
    ctrlpanel: 'True'
    fc: freq_mhz*1e6
    fftsize: '512'
    name: '"Canal (48 kHz)"'
    type: complex
  states: {}

connections:
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_agc2_xx_0, '0']
- [analog_agc2_xx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
